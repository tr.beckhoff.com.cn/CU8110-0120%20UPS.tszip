TYPE dataDUT :
STRUCT
	name:WSTRING;
	old:INT;
	sex:WSTRING;
	height:WSTRING;
	weight:WSTRING;
END_STRUCT
END_TYPE
